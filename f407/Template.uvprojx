# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE
  c include: .\Libraries\CMSIS;.\Libraries\STM32F4xx_HAL_Driver\Inc;.\User;.\Public;.\APP\led;.\APP\beep;.\APP\ws2812;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\rng;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\iic;.\APP\24Cxx;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\lv_port;.\APP\ui;.\Middlewares\lvgl;.\APP\mpu6050;.\APP\pedometer;.\APP\proto;.\APP\usart_c3;.\APP\mic;.\APP\voice;.\Middlewares\FreeRTOS\include;.\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c stm32f4xx_hal_timebase_tim.c system_stm32f4xx.c
    ./Middlewares/FreeRTOS/: tasks.c queue.c list.c
    ./Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ./Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f407xx.s
  group HAL_Driver
    ./Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_can.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c
  group CMSIS
    ./Libraries/CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group APP
    ./APP/led/: led.c
    ./APP/beep/: beep.c
    ./APP/ws2812/: ws2812.c
    ./APP/iic/: iic.c
    ./APP/mpu6050/: mpu6050.c
    ./APP/ds18b20/: ds18b20.c
    ./APP/rtc/: rtc.c
    ./APP/pedometer/: pedometer.c
    ./APP/eeprom/: eeprom.c
    ./APP/proto/: proto.c
    ./APP/usart_c3/: usart_c3.c
    ./APP/mic/: mic.c
    ./APP/voice/: voice.c
    ./APP/tftlcd/: tftlcd.c
  group LVGL
    ./APP/key/: key.c
    ./APP/lv_port/: lv_port_disp.c lv_port_indev.c
    ./APP/ui/: ui.c ui_home.c ui_time.c ui_steps.c ui_calib.c ui_settime.c ui_alert.c ui_timer.c ui_calc.c ui_games.c ui_snake.c ui_pong.c ui_tetris.c ui_weather.c ui_voice.c lv_font_chinese_16_trial.c
    ./Middlewares/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./Middlewares/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ./Middlewares/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./Middlewares/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./Middlewares/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ./Middlewares/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ./Middlewares/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./Middlewares/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./Middlewares/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./Middlewares/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ./Middlewares/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./Middlewares/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./Middlewares/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./Middlewares/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./Middlewares/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./Middlewares/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./Middlewares/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./Middlewares/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./Middlewares/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./Middlewares/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./Middlewares/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./Middlewares/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ./Middlewares/lvgl/src/extra/: lv_extra.c
    ./Middlewares/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./Middlewares/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./Middlewares/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ./Middlewares/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ./Middlewares/lvgl/src/extra/others/monkey/: lv_monkey.c
    ./Middlewares/lvgl/src/extra/others/msg/: lv_msg.c
    ./Middlewares/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./Middlewares/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./Middlewares/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./Middlewares/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./Middlewares/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./Middlewares/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./Middlewares/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./Middlewares/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./Middlewares/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./Middlewares/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./Middlewares/lvgl/src/extra/widgets/led/: lv_led.c
    ./Middlewares/lvgl/src/extra/widgets/list/: lv_list.c
    ./Middlewares/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./Middlewares/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./Middlewares/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./Middlewares/lvgl/src/extra/widgets/span/: lv_span.c
    ./Middlewares/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./Middlewares/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./Middlewares/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./Middlewares/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./Middlewares/lvgl/src/extra/widgets/win/: lv_win.c
    ./Middlewares/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ./Middlewares/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./Middlewares/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./Middlewares/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Public
    ./Public/: system.c SysTick.c usart.c
